SRC_URI += "file://user_2019-06-25-01-56-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

