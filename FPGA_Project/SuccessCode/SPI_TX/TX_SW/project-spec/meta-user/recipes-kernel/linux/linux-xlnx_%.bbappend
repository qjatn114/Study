SRC_URI += "file://user_2019-06-24-17-30-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

