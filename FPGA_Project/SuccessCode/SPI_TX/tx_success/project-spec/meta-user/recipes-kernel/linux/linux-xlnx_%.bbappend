SRC_URI += "file://user_2019-06-23-11-55-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

