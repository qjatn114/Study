SRC_URI += "file://user_2019-06-25-22-39-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

